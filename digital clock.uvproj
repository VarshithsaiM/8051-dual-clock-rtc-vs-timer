# Keil uVision project digital clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: digital clock +hex
  c flags: Optimize=9
  group Source Group 1
    ./: STARTUP.A51 clock.c
